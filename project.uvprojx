# Keil uVision project project.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Project\RTOS\include;.\Project\driver\dri_dev\include;.\Project\Tasks\include;.\Project\common;.\Project\User
  asm include: .\Project\RTOS\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Project/Startup/: startup_stm32f40_41xxx.s
  group RTOS
    ./Project/RTOS/source/: rtos.c
  group User
    ./Project/User/: main.c system.c delay.c
  group dri_dev
    ./Project/driver/dri_dev/source/: led.c beep.c key.c usart.c tpad.c dht11.c oled.c
    ./Project/driver/dri_dev/include/: oledfont.h
  group tasks
    ./Project/Tasks/source/: task.c
software components: CMSIS:CORE 6.1.0
